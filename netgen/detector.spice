* NGSPICE file created from detector.ext - technology: sky130A

.subckt detector din db do GND
X0 din nd sky130_fd_pr__cap_mim_m3_2 l=8.7e+07u w=8.7e+07u
X1 do GND sky130_fd_pr__cap_mim_m3_2 l=2.2e+07u w=2.2e+07u
X2 do nd GND sky130_fd_pr__res_xhigh_po w=350000u l=1.75e+07u
X3 GND db nd GND sky130_fd_pr__nfet_01v8 w=9e+06u l=150000u
.ends
